# Disable this recipe - using 6.6 instead
COMPATIBLE_MACHINE = "^$"
